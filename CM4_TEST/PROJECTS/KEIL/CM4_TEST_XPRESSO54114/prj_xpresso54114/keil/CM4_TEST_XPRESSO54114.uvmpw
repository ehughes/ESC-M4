<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>Peripheral examples</WorkspaceName>

  <project>
    <PathAndName>.\lib_chip_5411x\lib_chip_5411x.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\CM4_TEST_XPRESSO54114\CM4_TEST_XPRESSO54114.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\lib_board_lpcxpresso_54114\lib_board_lpcxpresso_54114.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>..\..\..\..\..\COMMON\LIB\KEIL\CMSIS_DSP_4_5.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

</ProjectWorkspace>
