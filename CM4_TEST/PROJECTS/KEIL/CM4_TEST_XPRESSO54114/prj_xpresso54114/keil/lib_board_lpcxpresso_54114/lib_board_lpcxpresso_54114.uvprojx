# Keil uVision project lib_board_lpcxpresso_54114.uvprojx, settings and files
target lib_board_lpcxpresso_54114 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_board_lpcxpresso_54114 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5411X CORE_M4
  c include: ..\..\..\chip_5411x\inc;..\..\..\brd_xpresso54114\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group src
    ../../../brd_xpresso54114/src/: board.c board_sysinit.c
