# Keil uVision project CM4_TEST_XPRESSO54114.uvprojx, settings and files
target iflash_nxp_lpcxpresso_lpc5411X (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CM4_TEST_XPRESSO54114
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: CHIP_LPC5411X CORE_M4,ARM_MATH_CM4,__FPU_PRESENT=1,BOARD=2,ABI=1,BUILD_CONFIG=3
  c include: ..\..\..\chip_5411x\inc;..\..\..\brd_xpresso54114\inc;..\..\..\..\..\..\COMMON\SRC\CMSIS_DSP_4_5\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group src
    ../../../examples_5411x/periph_blinky/: readme.txt
    ../../../chip_5411x/startup/: sysinit.c keil_startup_lpc5411x.s
    ../../../../../../COMMON/SRC/TEST/: CM_TEST.c CM_TEST_CONFIG.h Goertzel.h IIR.h IIR.c Goertzel.c cr_section_macros.h
  group libs
    ../lib_chip_5411x/keil_output/core_m4/: lib_chip_5411x.lib
    ../lib_board_lpcxpresso_54114/keil_output/core_m4/: lib_board_lpcxpresso_54114.lib
    ../../../chip_5411x/libs/: keil_lib_power.lib
    ../../../../../../COMMON/LIB/KEIL/LIB/: CMSIS_DSP_4_5_O3.lib
