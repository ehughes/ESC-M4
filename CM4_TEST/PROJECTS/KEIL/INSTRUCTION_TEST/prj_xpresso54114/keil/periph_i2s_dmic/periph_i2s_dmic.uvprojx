# Keil uVision project periph_i2s_dmic.uvprojx, settings and files
target iflash_nxp_lpcxpresso_lpc5411X (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.2.0-dev2
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2s_dmic_demo
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5411X CORE_M4
  c include: ..\..\..\chip_5411x\inc;..\..\..\brd_xpresso54114\inc;..\..\..\examples_5411x\periph_i2s_dmic\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group src
    ../../../examples_5411x/periph_i2s_dmic/: readme.txt
    ../../../chip_5411x/startup/: keil_startup_lpc5411x.s
    ./../../../chip_5411x/startup/: sysinit.c
    ../../../examples_5411x/periph_i2s_dmic/src/: i2s_dmic_demo.c audio_pll.c audio_pll.h clkout.c delay.c dmic_if.c i2c_if.c i2s_if.c wm8904.c wm8904_config.c
  group libs
    ../lib_chip_5411x/keil_output/core_m4/: lib_chip_5411x.lib
    ../lib_board_lpcxpresso_54114/keil_output/core_m4/: lib_board_lpcxpresso_54114.lib
    ../../../chip_5411x/libs/: keil_lib_power.lib
