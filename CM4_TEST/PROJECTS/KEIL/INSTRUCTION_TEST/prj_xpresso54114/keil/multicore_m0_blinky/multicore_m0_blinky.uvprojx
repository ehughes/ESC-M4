# Keil uVision project multicore_m0_blinky.uvprojx, settings and files
target iflash_nxp_lpc5411x (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.1.2.0-dev2
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: m0_blinky
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CHIP_LPC5411X CORE_M0PLUS __MULTICORE_M0SLAVE
  c include: ..\..\..\chip_5411x\inc;..\..\..\brd_xpresso54114\inc
  asm define: SLAVEBOOT NO_CRP
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group example
    ../../../examples_5411x/multicore_m0slave_blinky/src/: m0slave_blinky.c
    ../../../examples_5411x/multicore_m0slave_blinky/: readme.txt
    ../../../chip_5411x/startup/: sysinit.c keil_startup_lpc5411x-m0.s
  group lib
    ../lib_chip_5411x_m0/keil_output/core_m0/: lib_chip_5411x_m0.lib
    ../../../chip_5411x/libs/: keil_lib_power_m0.lib
