# IAR project usbdrom_audio.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54102J256_M4 NXP LPC54102J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050, Pa082
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; ..\..\..\examples_5411x\usbdrom_audio\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: usbdrom_audio.bin
  ILINK.IlinkIcfFile: ..\support\LPC5411x.icf
  ILINK.IlinkOutputFile: usbdrom_audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../examples_5411x/usbdrom_audio/src/: audio_codec.c audio_desc.c audio_main.c audio_usbd.c delay.c i2c_if.c i2s_if.c main.c pll_setup.c Power_Tasks.c wm8904.c wm8904_config.c
    ../../../chip_5411x/startup/: iar_startup_lpc5411x.s sysinit.c
    ../../../examples_5411x/usbdrom_audio/: readme.txt
  group lib
    ../lib_board_lpcxpresso_54114/iar_output/Exe/: board_lpcxpresso_54114.a
    ../lib_chip_5411x/iar_output/Exe/: chip_5411x_lib.a
    ../../../chip_5411x/libs/: iar_lib_power.a
