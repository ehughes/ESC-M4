# IAR project FlashNXPLPC54xxx.ewp, settings and files
configuration FlashNXPLPC54xxM0PL_RAM64K (ARM, debug)
  General.OGChipSelectEditMenu: LPC54102J512_M0PL NXP LPC54102J512_M0PL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_ARGC_ARGV=1
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashNXPLPC18xx.srec
  ILINK.IlinkOutputFile: FlashNXPLPC54xxxM0PL_RAM64K.out
  ILINK.IlinkIcfFile: FlashNXP64kRAM.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration FlashNXPLPC54xxM4F_RAM64K (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.CoreVariant: 39
  General.FPU2: 4
  ILINK.IlinkOutputFile: FlashNXPLPC54xxxM4F_RAM64K.out
  group (top)
    ./: FlashNXPLPC54xxx.c FlashNXPLPC54xxx.h
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
