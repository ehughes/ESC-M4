# IAR project lib_swim.ewp, settings and files
configuration swim (ARM, debug)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; ..\..\..\..\swim\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group lib_swim
    ../../../../swim/src/: lpc_colors.c lpc_fonts.c lpc_helvr10.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_swim_image_mono.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c
