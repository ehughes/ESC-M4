# IAR project lib_chip_5411x_m0.ewp, settings and files
configuration chip_5411x_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC54102J256_M0PL NXP LPC54102J256_M0PL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group inc
    ../../../chip_5411x/inc/: adc_5411x.h chip.h clock_5411x.h cmsis.h cmsis_5411x.h cmsis_5411x_m0.h core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h cpuctrl_5411x.h crc_5411x.h dma_5411x.h error.h flexcomm_5411x.h fpu_init.h gpio_5411x.h gpiogroup_5411x.h i2c_common_5411x.h i2cm_5411x.h i2cs_5411x.h iap.h inmux_5411x.h iocon_5411x.h lpc_assert.h lpc_types.h mailbox_5411x.h mrt_5411x.h packing.h pinint_5411x.h pintable_5411x.h pll_5411x.h pmu_5411x.h power_lib_5411x.h ring_buffer.h rom_i2c_5411x.h rom_pwr_5411x.h rom_uart_5411x.h romapi_5411x.h rtc_5411x.h rtc_ut.h sct_5411x.h sct_pwm_5411x.h spi_common_5411x.h spim_5411x.h spis_5411x.h stopwatch.h syscon_5411x.h timer_5411x.h uart_5411x.h usbd.h usbd_adc.h usbd_cdc.h usbd_cdcuser.h usbd_core.h usbd_desc.h usbd_dfu.h usbd_dfuuser.h usbd_hid.h usbd_hiduser.h usbd_hw.h usbd_msc.h usbd_mscuser.h usbd_rom_api.h utick_5411x.h wwdt_5411x.h
  group libs
    ../../../chip_5411x/libs/: iar_lib_power_m0.a
  group src
    ../../../chip_5411x/src/: adc_5411x.c chip_5411x.c clock_5411x.c dma_5411x.c dma_service_5411x.c dmic_5411x.c flexcomm_5411x.c fpu_init.c i2cm_5411x.c i2cs_5411x.c iap.c pll_5411x.c ring_buffer.c rtc_ut.c sct_5411x.c sct_pwm_5411x.c spi_common_5411x.c spim_5411x.c spis_5411x.c stopwatch_5411x.c syscon_5411x.c sysinit_5411x.c timer_5411x.c uart_5411x.c
