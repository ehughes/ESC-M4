# IAR project multicore_m0_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M0PL NXP LPC54102J512_M0PL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; __MULTICORE_M0SLAVE; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SLAVEBOOT; NO_CRP
  OBJCOPY.OOCOutputFile: multicore_m0_blinky.bin
  ILINK.IlinkOutputFile: multicore_m0_blinky.out
  ILINK.IlinkIcfFile: LPC5411x_m0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../chip_5411x/startup/: iar_startup_lpc5411x-m0.s sysinit.c
    ../../../examples_5411x/multicore_m0slave_blinky/src/: m0slave_blinky.c
    ../../../examples_5411x/multicore_m0slave_blinky/: readme.txt
  group lib
    ../lib_chip_5411x_m0/iar_output_m0/Exe/: chip_5411x_lib_m0.a
    ../../../chip_5411x/libs/: iar_lib_power_m0.a
