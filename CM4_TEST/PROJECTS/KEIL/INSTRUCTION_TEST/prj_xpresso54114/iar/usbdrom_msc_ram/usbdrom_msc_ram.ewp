# IAR project usbdrom_msc_ram.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54102J256_M4 NXP LPC54102J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; ..\..\..\examples_5411x\usbdrom_msc_ram\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: usbdrom_msc_ram.bin
  ILINK.IlinkIcfFile: ..\support\LPC5411x.icf
  ILINK.IlinkOutputFile: usbdrom_msc_ram.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../chip_5411x/startup/: iar_startup_lpc5411x.s sysinit.c
    ../../../examples_5411x/usbdrom_msc_ram/src/: msc_desc.c msc_main.c msc_ram.c ramdisk.c
    ../../../examples_5411x/periph_blinky/: readme.txt
  group lib
    ../lib_board_lpcxpresso_54114/iar_output/Exe/: board_lpcxpresso_54114.a
    ../lib_chip_5411x/iar_output/Exe/: chip_5411x_lib.a
    ../../../chip_5411x/libs/: iar_lib_power.a
