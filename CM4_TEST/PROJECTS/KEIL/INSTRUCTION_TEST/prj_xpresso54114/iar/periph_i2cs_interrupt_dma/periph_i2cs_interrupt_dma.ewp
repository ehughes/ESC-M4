# IAR project periph_i2cs_interrupt_dma.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54101J512_M4 NXP LPC54101J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: i2cs_interrupt_dma.bin
  ILINK.IlinkIcfFile: ..\support\LPC5411x.icf
  ILINK.IlinkOutputFile: i2cs_interrupt_dma.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../examples_5411x/periph_i2cs_interrupt_dma/src/: i2cs_interrupt_dma.c
    ../../../chip_5411x/startup/: iar_startup_lpc5411x.s sysinit.c
    ../../../examples_5411x/periph_i2cs_interrupt_dma/: readme.txt
  group lib
    ../lib_board_lpcxpresso_54114/iar_output/Exe/: board_lpcxpresso_54114.a
    ../lib_chip_5411x/iar_output/Exe/: chip_5411x_lib.a
    ../../../chip_5411x/libs/: iar_lib_power.a
