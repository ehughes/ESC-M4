# IAR project periph_i2s_dmic.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54114 (ARM)
  General.OGChipSelectEditMenu: LPC54101J512_M4 NXP LPC54101J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CHIP_LPC5411X
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\chip_5411x\inc; ..\..\..\brd_xpresso54114\inc; ..\..\..\examples_5411x\periph_i2s_dmic\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: periph_i2s_dmic.bin
  ILINK.IlinkIcfFile: ..\support\LPC5411x.icf
  ILINK.IlinkOutputFile: i2s.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../examples_5411x/periph_i2s_dmic/src/: audio_pll.c audio_pll.h clkout.c delay.c dmic_if.c i2c_if.c i2s_dmic_demo.c i2s_if.c wm8904.c wm8904_config.c
    ../../../chip_5411x/startup/: iar_startup_lpc5411x.s sysinit.c
    ../../../examples_5411x/periph_i2s_dmic/: readme.txt
  group lib
    ../lib_board_lpcxpresso_54114/iar_output/Exe/: board_lpcxpresso_54114.a
    ../lib_chip_5411x/iar_output/Exe/: chip_5411x_lib.a
    ../../../chip_5411x/libs/: iar_lib_power.a
