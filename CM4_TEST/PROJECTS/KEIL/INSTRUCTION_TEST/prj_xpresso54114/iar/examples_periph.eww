<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lib_chip_5411x\lib_chip_5411x.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lib_board_lpcxpresso_54114\lib_board_lpcxpresso_54114.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_blinky_color\periph_blinky_color.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_dma\periph_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_dmic\periph_dmic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_flashiap\periph_flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_freqmeasure\periph_freqmeasure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_gint\periph_gint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm\periph_i2cm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cs_interrupt\periph_i2cs_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cs_interrupt_dma\periph_i2cs_interrupt_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2s\periph_i2s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2s_dmic\periph_i2s_dmic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_mrt\periph_mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pllfract\periph_pllfract.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pmu\periph_pmu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_rtcut\periph_rtcut.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct\periph_sct.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct_pwm\periph_sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi_sm_dma\periph_spi_sm_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi_sm_int\periph_spi_sm_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi_sm_poll\periph_spi_sm_poll.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_timer\periph_timer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_dma\periph_uart_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rb\periph_uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_utick\periph_utick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_wwdt\periph_wwdt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>lib_board_lpcxpresso_54114</project>
        <configuration>brd_xpresso54114</configuration>
      </member>
      <member>
        <project>lib_chip_5411x</project>
        <configuration>chip_5411x_lib</configuration>
      </member>
      <member>
        <project>periph_adc</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_blinky_color</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_dma</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_dmic</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_flashiap</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_freqmeasure</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_gint</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_i2cm</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_i2cs_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_i2cs_interrupt_dma</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_i2s</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_i2s_dmic</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_mrt</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_pinint</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_pllfract</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_pmu</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_rtc</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_rtcut</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_sct</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_sct_pwm</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_spi_sm_dma</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_spi_sm_int</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_spi_sm_poll</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_timer</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_uart_dma</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_uart_rb</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_utick</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
      <member>
        <project>periph_wwdt</project>
        <configuration>iflash_nxp_lpcxpresso_54114</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


